# Repository ErPournima56/USB_POWER_BREAKOUT_BOARD

File README.md:

# USB_POWER_BREAKOUT_BOARD
This is a simple, compact USB power breakout board designed in KiCad. Useful for power access and USB-based embedded projects.

## KiCad design USB_PWR_BRKOUT.kicad_pcb

Board: 2 copper layers, 19.7 x 20.0 mm, 4 parts (0 on the bottom side), 5 nets.

Parts:
D1: L1; LED_D1.8mm_W3.3mm_H2.4mm
J1: USB_A; USB_A_Molex_67643_Horizontal
J2: Conn; PinHeader_1x04_P2.00mm_Vertical
R1: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical

Connections:
/D+: J1.3 (D+), J2.2
/D-: J1.2 (D-), J2.3
/GND: D1.1 (K), J1.4 (GND), J2.1
/PWR: J1.1 (VBUS), J2.4, R1.1
unnamed: D1.2 (A), R1.2

## Commit log

2025-07-03 Create LICENSE
